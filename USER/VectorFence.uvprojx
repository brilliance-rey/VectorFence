# Keil uVision project VectorFence.uvprojx, settings and files
target VectorFence (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: VectorFence +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\FWLIB\STM32F4xx_StdPeriph_Driver\inc;..\FWLIB\STM32F4x7_ETH_Driver\inc;..\USER;..\MALLOC;..\HARDWARE\ADC;..\HARDWARE\KEY;..\HARDWARE\ETHERNET;..\HARDWARE\ALARM;..\HARDWARE\24CXX;..\HARDWARE\LED;..\HARDWARE\LCD;..\HARDWARE\PWM;..\HARDWARE\IIC;..\HARDWARE\LOG;..\HARDWARE\LM75;..\HARDWARE\PCF8563;..\HARDWARE\RS485;..\HARDWARE\TIMER;..\USMART;..\UCOSII\CORE;..\UCOSII\PORT;..\UCOSII\CONFIG;..\LWIP;..\LWIP\arch;..\LWIP\lwip_app\lwip_comm;..\LWIP\lwip-1.4.1\src\include;..\LWIP\lwip-1.4.1\src\include\ipv4;..\LWIP\lwip-1.4.1\src\include\lwip;..\LWIP\lwip-1.4.1\src\include\netif;..\LWIP\lwip_app\tcp_client;..\LWIP\lwip_app\tcp_server;..\LWIP\lwip_app\udp_comm;..\LWIP\lwip_app\web_server;..\SYSTEM\version
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/IIC/: myiic.c iicrw.c
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/LM75/: lm75.c
    ../HARDWARE/ETHERNET/: lan8720.c
    ../HARDWARE/PCF8563/: pcf8563.c
    ../HARDWARE/ALARM/: alarm.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LCD/: lcd.c DisplayMenu.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/LOG/: log.c
    ../HARDWARE/RS485/: RS485.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/version/: version.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_adc.c stm32f4xx_fsmc.c stm32f4xx_tim.c stm32f4xx_exti.c
    ../FWLIB/STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
  group UCOSII-CORE
    ../UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSII-PORT
    ../UCOSII/PORT/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group UCOSII-CONFIG
    ../UCOSII/CONFIG/: includes.h os_cfg.h
  group LWIP-APP
    ../LWIP/lwip_app/lwip_comm/: lwip_comm.c
    ../LWIP/lwip_app/web_server/: fs.c httpd.c httpd_cgi_ssi.c
    ../LWIP/lwip_app/tcp_server/: tcp_server.c
  group LWIP-NETIF
    ../LWIP/lwip-1.4.1/src/netif/: etharp.c ethernetif.c
  group LWIP-CORE
    ../LWIP/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../LWIP/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c memp.c netif.c pbuf.c raw.c stats.c tcp.c tcp_in.c tcp_out.c timers.c udp.c mem.c
  group LWIP-ARCH
    ../LWIP/arch/: sys_arch.c
  group LWIP-API
    ../LWIP/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group MALLOC
    ../MALLOC/: malloc.c
  group README
    ../: readme.txt
